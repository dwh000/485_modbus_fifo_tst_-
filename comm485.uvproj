# Keil uVision project comm485.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC130LD2CN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: comm485 +hex
  c flags: Optim=1 OneElfS=1
  c include: .\BSP_lib\Inc\Driver;.\CMSIS\CMOSupport;.\CMSIS\NUC1xxSupport;.\User\inc;.\modbus\include;.\modbus\MBport;.\modbus\rtu
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./User/src/: main.c IO_logic.c public.c UartAPI.c
  group MbPort
    ./modbus/MBport/: port.c portevent.c portserial.c porttimer.c
  group MbCode
    ./modbus/rtu/: mbcrc.c mbrtu.c
    ./modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./modbus/: mb.c
  group BSP_LIB
    ./BSP_lib/Src/Driver/: DrvGPIO.c DrvSYS.c DrvTIMER.c DrvUART.c retarget.c
  group CMSIS
    ./CMSIS/CMOSupport/: core_cm0.c
    ./CMSIS/NUC1xxSupport/: system_NUC1xx.c
    ./CMSIS/STARTUP/: startup_NUC1xx.s
